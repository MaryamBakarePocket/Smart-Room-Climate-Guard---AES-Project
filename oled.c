#include <string.h>
#include <stdbool.h>
#include "oled.h"
#include "driver/i2c_master.h"
#include "esp_log.h"

#define OLED_ADDR   0x3C            /* some modules use 0x3D */
#define OLED_W      128
#define OLED_PAGES  4               /* 32 pixels / 8 */
#define CHAR_W      6               /* 5 pixels + 1 blank column */

static const char *TAG = "oled";
static i2c_master_dev_handle_t s_dev;
static uint8_t s_fb[OLED_W * OLED_PAGES];
static bool s_ready = false;

/* 5x7 font, ASCII 32..126, one byte per column (bit0 = top pixel) */
static const uint8_t FONT[95][5] = {
    {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},
    {0x14,0x7F,0x14,0x7F,0x14},{0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},
    {0x36,0x49,0x56,0x20,0x50},{0x00,0x08,0x07,0x03,0x00},{0x00,0x1C,0x22,0x41,0x00},
    {0x00,0x41,0x22,0x1C,0x00},{0x2A,0x1C,0x7F,0x1C,0x2A},{0x08,0x08,0x3E,0x08,0x08},
    {0x00,0x80,0x70,0x30,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x00,0x60,0x60,0x00},
    {0x20,0x10,0x08,0x04,0x02},{0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},
    {0x72,0x49,0x49,0x49,0x46},{0x21,0x41,0x49,0x4D,0x33},{0x18,0x14,0x12,0x7F,0x10},
    {0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x31},{0x41,0x21,0x11,0x09,0x07},
    {0x36,0x49,0x49,0x49,0x36},{0x46,0x49,0x49,0x29,0x1E},{0x00,0x00,0x14,0x00,0x00},
    {0x00,0x40,0x34,0x00,0x00},{0x00,0x08,0x14,0x22,0x41},{0x14,0x14,0x14,0x14,0x14},
    {0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x59,0x09,0x06},{0x3E,0x41,0x5D,0x59,0x4E},
    {0x7C,0x12,0x11,0x12,0x7C},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
    {0x7F,0x41,0x41,0x41,0x3E},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},
    {0x3E,0x41,0x41,0x51,0x73},{0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},
    {0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},{0x7F,0x40,0x40,0x40,0x40},
    {0x7F,0x02,0x1C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
    {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},
    {0x26,0x49,0x49,0x49,0x32},{0x03,0x01,0x7F,0x01,0x03},{0x3F,0x40,0x40,0x40,0x3F},
    {0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},{0x63,0x14,0x08,0x14,0x63},
    {0x03,0x04,0x78,0x04,0x03},{0x61,0x59,0x49,0x4D,0x43},{0x00,0x7F,0x41,0x41,0x41},
    {0x02,0x04,0x08,0x10,0x20},{0x00,0x41,0x41,0x41,0x7F},{0x04,0x02,0x01,0x02,0x04},
    {0x40,0x40,0x40,0x40,0x40},{0x00,0x03,0x07,0x08,0x00},{0x20,0x54,0x54,0x78,0x40},
    {0x7F,0x28,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x28},{0x38,0x44,0x44,0x28,0x7F},
    {0x38,0x54,0x54,0x54,0x18},{0x00,0x08,0x7E,0x09,0x02},{0x18,0xA4,0xA4,0x9C,0x78},
    {0x7F,0x08,0x04,0x04,0x78},{0x00,0x44,0x7D,0x40,0x00},{0x20,0x40,0x40,0x3D,0x00},
    {0x7F,0x10,0x28,0x44,0x00},{0x00,0x41,0x7F,0x40,0x00},{0x7C,0x04,0x78,0x04,0x78},
    {0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},{0xFC,0x18,0x24,0x24,0x18},
    {0x18,0x24,0x24,0x18,0xFC},{0x7C,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x24},
    {0x04,0x04,0x3F,0x44,0x24},{0x3C,0x40,0x40,0x20,0x7C},{0x1C,0x20,0x40,0x20,0x1C},
    {0x3C,0x40,0x30,0x40,0x3C},{0x44,0x28,0x10,0x28,0x44},{0x4C,0x90,0x90,0x90,0x7C},
    {0x44,0x64,0x54,0x4C,0x44},{0x00,0x08,0x36,0x41,0x00},{0x00,0x00,0x77,0x00,0x00},
    {0x00,0x41,0x36,0x08,0x00},{0x02,0x01,0x02,0x04,0x02},
};

static esp_err_t send_cmd(uint8_t c)
{
    uint8_t b[2] = {0x00, c};
    return i2c_master_transmit(s_dev, b, sizeof b, 100);
}

esp_err_t oled_init(gpio_num_t sda, gpio_num_t scl)
{
    i2c_master_bus_config_t bus_cfg = {
        .i2c_port = I2C_NUM_0,
        .sda_io_num = sda,
        .scl_io_num = scl,
        .clk_source = I2C_CLK_SRC_DEFAULT,
        .glitch_ignore_cnt = 7,
        .flags.enable_internal_pullup = true,
    };
    i2c_master_bus_handle_t bus;
    esp_err_t err = i2c_new_master_bus(&bus_cfg, &bus);
    if (err != ESP_OK) {
        return err;
    }

    err = i2c_master_probe(bus, OLED_ADDR, 100);      /* is anything there? */
    if (err != ESP_OK) {
        ESP_LOGW(TAG, "No OLED answered at 0x%02X (check SDA/SCL wiring and address)", OLED_ADDR);
        i2c_del_master_bus(bus);
        return err;
    }

    i2c_device_config_t dev_cfg = {
        .dev_addr_length = I2C_ADDR_BIT_LEN_7,
        .device_address = OLED_ADDR,
        .scl_speed_hz = 400000,
    };
    err = i2c_master_bus_add_device(bus, &dev_cfg, &s_dev);
    if (err != ESP_OK) {
        i2c_del_master_bus(bus);
        return err;
    }

    static const uint8_t init_seq[] = {
        0xAE,             /* display off */
        0xD5, 0x80,       /* clock */
        0xA8, 0x1F,       /* multiplex: 32 rows */
        0xD3, 0x00,       /* display offset */
        0x40,             /* start line */
        0x8D, 0x14,       /* charge pump on */
        0x20, 0x00,       /* horizontal addressing */
        0xA1, 0xC8,       /* flip so text is not upside down / mirrored */
        0xDA, 0x02,       /* COM pins for 128x32 */
        0x81, 0x8F,       /* contrast */
        0xD9, 0xF1,
        0xDB, 0x40,
        0xA4, 0xA6,       /* show RAM, normal (not inverted) */
        0xAF,             /* display on */
    };
    for (size_t i = 0; i < sizeof init_seq; i++) {
        err = send_cmd(init_seq[i]);
        if (err != ESP_OK) {
            return err;
        }
    }

    s_ready = true;
    oled_clear();
    oled_show();
    return ESP_OK;
}

void oled_clear(void)
{
    memset(s_fb, 0, sizeof s_fb);
}

void oled_text(int row, const char *str)
{
    if (row < 0 || row >= OLED_PAGES || str == NULL) {
        return;
    }
    int x = 0;
    for (; *str && x + CHAR_W <= OLED_W; str++, x += CHAR_W) {
        unsigned char c = (unsigned char)*str;
        if (c < 32 || c > 126) {
            c = '?';
        }
        memcpy(&s_fb[row * OLED_W + x], FONT[c - 32], 5);
        s_fb[row * OLED_W + x + 5] = 0x00;
    }
}

void oled_show(void)
{
    if (!s_ready) {
        return;
    }
    send_cmd(0x21); send_cmd(0); send_cmd(OLED_W - 1);      /* columns 0..127 */
    send_cmd(0x22); send_cmd(0); send_cmd(OLED_PAGES - 1);  /* pages 0..3 */
    uint8_t buf[1 + OLED_W];
    for (int pg = 0; pg < OLED_PAGES; pg++) {
        buf[0] = 0x40;                                      /* data follows */
        memcpy(buf + 1, &s_fb[pg * OLED_W], OLED_W);
        i2c_master_transmit(s_dev, buf, sizeof buf, 100);
    }
}
